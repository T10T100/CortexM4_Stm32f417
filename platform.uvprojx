# Keil uVision project platform.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F417IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: platform +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: tftili9486,
  c misc: --cpp11
  c include: .\entry\inc;.\gui\inc;.\hardware\inc;.\misc\inc;..\stm32cubef4\STM32Cube_FW_F4_V1.6.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\stm32cubef4\STM32Cube_FW_F4_V1.6.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\stm32cubef4\STM32Cube_FW_F4_V1.6.0\Drivers\CMSIS\Include;.\hardware\Drivers\inc;.\misc\context\inc
  asm define: stackSwitching
  asm include: .\misc\inc;..\platform
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\platform.sct
  group entry
    ./entry/src/: main.cpp
  group hardware
    ./hardware/src/: device.cpp gpio_ex.cpp init.cpp
  group drivers
    ../stm32cubef4/STM32Cube_FW_F4_V1.6.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
  group iT
    ./entry/src/: stm32f4xx_it.c
  group misc
    ./misc/src/: memory_alloc.cpp
  group context
    ./misc/context/src/: stackSwitching.s contextSwitching.cpp
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 2.1.0
